# This is the work-around solution for running error in XBMC

SRC_URI_remove_mx6 = " file://strcoll-Remove-incorrect-STRDIFF-based-optimization-.patch"
