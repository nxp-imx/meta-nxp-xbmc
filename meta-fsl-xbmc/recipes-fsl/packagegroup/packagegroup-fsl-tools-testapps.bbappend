# Add needed Freescale packages and definitions
SOC_TOOLS_TESTAPPS_mx6 += " xbmc xbmc-nm-addon networkmanager xbmc-image-custom-rfs "

