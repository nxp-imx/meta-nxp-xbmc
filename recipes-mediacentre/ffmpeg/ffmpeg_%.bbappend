# The following line prevents a failure in do_rootfs when building with SDK
RDEPENDS_${PN}-dev = ""
